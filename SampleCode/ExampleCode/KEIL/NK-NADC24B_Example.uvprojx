# Keil uVision project NK-NADC24B_Example.uvprojx, settings and files
target NK-NADC24B_Example (6240000::V6.24::ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) IROM2(0x00100000,0x1000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: NK-NADC24B_Example +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_MATH_ARMV8MBL=1, DEBUG_ENABLE=0
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\LCDLib\Include;..\SSD1306
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M251.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
    ../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.s
  group User
    ../: main.c NADC24B_Driver.c NADC24B_Driver.h LCD_Function.c
  group Library
    ../../../Library/StdDriver/src/: timer.c fmc.c gpio.c spi.c sys.c uart.c clk.c retarget.c i2c.c
    ../../../Library/CMSIS/Lib/ARM/: arm_ARMv8MBLl_math.lib
  group SSD1306
    ../SSD1306/: HAL_TICK_CONTROL.c HAL_TICK_CONTROL.h ssd1306.c ssd1306.h ssd1306_conf.h ssd1306_fonts.c ssd1306_fonts.h
